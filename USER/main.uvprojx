# Keil uVision project main.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32_FWLIB\inc;..\MyCode;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group MyCode
    ../MyCode/: DEFINE_GPIO.c SPI.c HC05.c ADC.c IR_sensor.c MAX6675.c VOLTAGE_SENSOR.c CURRENT_SENSOR.c PWM_CAPTURE.c X9C104.c TIMER.c MYIIC.c MPU6050.c DMA.c INA226.c PID.c Power.c Filter.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32_FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_adc.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
